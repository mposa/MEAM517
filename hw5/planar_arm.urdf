Commit message: updating files

File: hw5/planar_arm.urdf (robot description, URDF)
Before this commit: robot planar_arm, 5 links, 5 joints
Joints:
- joint joint_one: limit effort=100 -> effort=5
- joint joint_three: limit effort=100 -> effort=5
- joint joint_two: limit effort=100 -> effort=5
